# Keil uVision project MS3.uvproj, settings and files
target Target 1 (MCS-51)
  device: P89C61X2 Philips
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) XRAM(0-0x2FF) CLOCK(33000000) MODP2
  output: MS3 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
    ../SourceFile/: utility.c boot.c flash.c key.c message.c mmi.c routine.c rtc.c timer.c uart.c mcu.c trace.c mcu_ext.c putchar.c
